# Keil uVision project TARDIS_OS.uvprojx, settings and files
target TARDIS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: TARDIS_OS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./source/: main.c
    ./Source/: switch.c Bitmap.c List.c Time.c Task.c Cpu.c app.c Event.c Semaphore.c MessageBox.c MemoryBlock.c FlagGroup.c MutexSemaphore.c Timer.c Hooks.c
  group include
    ./include/: Config.h DS_Lib.h TARDIS_OS.h Event.h Task.h Semaphore.h MessageBox.h MemoryBlock.h FlagGroup.h MutexSemaphore.h Timer.h Hooks.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
